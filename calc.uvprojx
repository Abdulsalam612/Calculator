# Keil uVision project calc.uvprojx, settings and files
target Target 1 (6240000::V6.24::ARMCLANG)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: calc
  c flags: Optim=2 OneElfS=1 v6Lang=1 v6LangP=3 wLevel=3
  c include: .\src
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source Group 1
    ./src/: main.c lcd.c keypad.c PLL.c SysTick.c calculator.c
    ./: texas.o
software components: CMSIS:CORE 5.6.0, Device:Startup 1.0.1
